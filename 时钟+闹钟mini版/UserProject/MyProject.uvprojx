# Keil uVision project MyProject.uvprojx, settings and files
target MyPro (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyProject +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\UserProject;..\Core;..\STM32F103_Lib\inc;..\Hrd\LED;..\Hrd\KEY;..\delay;..\Hrd\EXTI;..\Hrd\TIM;..\Hrd\SMG;..\Hrd\BEEF
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group UserProject
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F103_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Hrd
    ../Hrd/LED/: led.c
    ../Hrd/KEY/: Key.c
    ../Hrd/TIM/: timer.c
    ../Hrd/SMG/: smg.c
    ../Hrd/BEEF/: beef.c
  group delay
    ../delay/: delay.c
